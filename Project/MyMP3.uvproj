# Keil uVision project MyMP3.uvproj, settings and files
target MyMP3 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Boot +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\BSC\inc;..\CMSIS;..\Fatfs;..\FWLib\inc;..\User;..\BSC\IAP;..\BSC\flash
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h
  group BSC
    ../BSC/src/: delay.c sdio.c usart.c
    ../BSC/IAP/: iap.c
    ../BSC/flash/: stmflash.c
  group FATFS
    ../Fatfs/: diskio.c ff.c
  group FWLib
    ../FWLib/src/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_flash.c misc.c
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
